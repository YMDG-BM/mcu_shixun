# Keil uVision project 51car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 51car +hex
  c flags: Optimize=8 SizeSpeed=1
  group project
    ./: STARTUP.A51
  group user
    ./: main.c
  group api
    ./: beep.c delay.c key.c lcd.c led.c spi.c
